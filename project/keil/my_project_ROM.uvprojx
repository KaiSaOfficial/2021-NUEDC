# Keil uVision project my_project_ROM.uvprojx, settings and files
target my_project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.0
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: my_project_rom
  AfterMake: fromelf --bin --output .\Build\my_project_ROM.bin .\Build\my_project_ROM.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__ ,ARM_MATH_CM4,CC_ARM,FPU_PRESENT=1,FPU_USED =1
  c include: ..\..\hardware\inc;..\..\package\MultiTimer;..\..\sys\inc;..\..\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02;..\..\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02\third_party\CMSIS\Include;..\..\hardware\inc;..\..\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02\third_party\CMSIS;..\..\software
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../../: system_msp432p401r.c main.c
    ./: startup_msp432p401r_uvision.s
  group Library
    ../../ti_driverlib/simplelink_msp432p4_sdk_3_40_01_02/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
  group SYS
    ../../sys/: usart.c sysinit.c delay.c baudrate_calculate.c
  group hardware
    ../../hardware/: led.c oled.c adc.c screen.c bluetooth.c
  group dsplib
    ../../dsplib/: arm_cortexM4lf_math.lib msp432p4xx_driverlib.lib
  group software
    ../../software/: fft_calculate.c
software components: CMSIS:CORE 4.3.0
